# Keil uVision project application_n5x.uvprojx, settings and files
target d52q_module (6160000::V6.16::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: application_d52q +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52, CONFIG_GPIO_AS_PINRESET, NRF52_RADIO, NRF52_N548_CONFIG, CONFIG_NFCT_PINS_AS_GPIOS, D52Q_MODULE, SOFTDEVICE_PRESENT, DEBUG
  c misc: --std=c99
  c include: .\inc;.\common\inc;..\..\..\components\libraries\util;..\..\..\components\libraries\delay;..\..\..\modules\nrfx;..\..\..\integration\nrfx;..\..\..\modules\nrfx\mdk;..\..\..\components\softdevice\s212\headers;..\..\..\components\softdevice\s212\headers\nrf52
  memory RVCT4: ROM 0x12000 size 0x50000
  memory RVCT9: RAM 0x20000b80 size 0x8000
  group main
    ./src/: main.c version.c
    ./common/src/: command.c dsi_utility.c serial.c global.c system.c event_buffering.c multi_ctx_fifo.c
target d52m_module (6160000::V6.16::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: application_d52m +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52, CONFIG_GPIO_AS_PINRESET, NRF52_RADIO, NRF52_N548_CONFIG, CONFIG_NFCT_PINS_AS_GPIOS, D52M_MODULE, SOFTDEVICE_PRESENT, DEBUG
  c misc: --std=c99
  c include: as above
  memory RVCT4: ROM 0x12000 size 0x50000
  memory RVCT9: RAM 0x20000b80 size 0x8000
target d52q_premium_module (6160000::V6.16::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: application_d52q_premium +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52, CONFIG_GPIO_AS_PINRESET, NRF52_RADIO, NRF52_N548_CONFIG, CONFIG_NFCT_PINS_AS_GPIOS, D52Q_PREMIUM_MODULE, SOFTDEVICE_PRESENT, DEBUG
  c misc: --std=c99
  c include: as above
  memory RVCT4: ROM 0x12000 size 0x50000
  memory RVCT9: RAM 0x20000b80 size 0x8000
target d52m_premium_module (6160000::V6.16::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: application_d52m_premium +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52, CONFIG_GPIO_AS_PINRESET, NRF52_RADIO, NRF52_N548_CONFIG, CONFIG_NFCT_PINS_AS_GPIOS, D52M_PREMIUM_MODULE, SOFTDEVICE_PRESENT, DEBUG
  c misc: --std=c99
  c include: as above
  memory RVCT4: ROM 0x12000 size 0x50000
  memory RVCT9: RAM 0x20000b80 size 0x8000
target nRF52832_generic (6160000::V6.16::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: application_nRF52832_generic +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52, CONFIG_GPIO_AS_PINRESET, NRF52_RADIO, NRF52_N548_CONFIG, CONFIG_NFCT_PINS_AS_GPIOS, SOFTDEVICE_PRESENT, DEBUG
  c misc: --std=c99
  c include: as above
  memory RVCT4: ROM 0x12000 size 0x50000
  memory RVCT9: RAM 0x20000b80 size 0x8000
target nRF52840_generic (6160000::V6.16::ARMCLANG)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: application_nRF52840_generic +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: --std=c99
  c include: as above
  memory RVCT4: ROM 0x12000 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000b80 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target xiao_nRF52840 (6160000::V6.16::ARMCLANG)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: application_xiao_nRF52840 +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52840_XXAA, CONFIG_GPIO_AS_PINRESET, NRF52_RADIO, NRF52_N548_CONFIG, CONFIG_NFCT_PINS_AS_GPIOS, XIAO_NRF52840, SOFTDEVICE_PRESENT, DEBUG
  c misc: --std=c99
  c include: as above
  memory RVCT4: ROM 0x12000 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000b80 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
software components: CMSIS:CORE 6.1.0, Device:Startup 8.44.1, Device:Startup 8.44.1
